# Keil uVision project timer.uvprojx, settings and files
target nrf51822_xxac (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: timer +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: BSP_DEFINES_ONLY BOARD_PCA10028 NRF51
  c include: ..\components\drivers_nrf\hal;..\components\drivers_nrf\common;..\bsp;..\..;..\components\libraries\util;..\config;..\components\drivers_nrf\nrf_soc_nosd;..\components\toolchain;..\components\drivers_nrf\timer;..\config;..\components\drivers_nrf\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./: main.c
  group nRF_Drivers
    ../components/drivers_nrf/common/: nrf_drv_common.c
    ../components/drivers_nrf/timer/: nrf_drv_timer.c
  group nRF_Libraries
    ../components/libraries/util/: app_error.c app_error_weak.c nrf_assert.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
